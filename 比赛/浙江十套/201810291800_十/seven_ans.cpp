#include<iostream>
using namespace std;
const int oi[101]={0,116,521,1160,886,155,363,840,840,1245,547,273,879,1087,227,344,749,51,51,657,865,5,122,527,1166,892,161,369,369,486,891,193,1256,525,733,1210,1327,395,395,669,63,1192,715,598,193,891,1165,559,559,82,1302,897,258,532,1263,1055,578,461,461,1159,96,827,619,142,25,957,318,592,592,800,1277,1277,1277,1277,1277,1277,1277,1277,1277,1277,1277,214,945,737,260,143,1075,436,436,1167,959,482,365,1297,658,932,326,118,118,1,933};
const int ob[101]={0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,1,1,0,0,0,0,0,1,1,0,0,0,0,0,1,1,0,0,0,0,0,1,1,0,0,0,0,0,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,0,0,0,0,0,1,1,0,0,0,0,0};
int x=0;
inline bool emm(int);
int main()
{
  register int i=0,j=1;
  register bool b=false;
  cin>>x;
  i=oi[x/10000000];
  b=ob[x/10000000];
  for(j+=max(x/10000000*10000000-1,0);j<x;++j)
  {
  	if(emm(j))
  	{
  	  b^=1;
	}
	if(b)
	{
	  --i;
	}
	else
	{
	  ++i;
	}
  }
  for(;i>1336;i-=1337);
  for(;i<0;i+=1337);
  cout<<i+1<<endl;
  return 0;
}
inline bool emm(int x)
{
  if(!(x%7))
  {
  	return true;
  }
  for(;x;x/=10)
  {
  	if(x%10==7)
  	{
  	  return true;
	}
  }
  return false;
}
