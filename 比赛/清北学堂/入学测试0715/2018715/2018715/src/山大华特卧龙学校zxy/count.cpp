#include<cstdio>
#include<iostream>
#include<algorithm>
using namespace std;
char a[10][10];
int b[30],t[50];
int cs,op;
int main()
{
	freopen("count.in","r",stdin);
	freopen("count.out","w",stdout);
	for(int i=1;i<=3;i++)
	  for(int j=1;j<=3;j++)
	    cin>>a[i][j];
	if(a[1][1]==a[1][2]&&a[1][1]==a[1][3]) b[a[1][1]-'A']++;
	if(a[2][1]==a[2][2]&&a[2][1]==a[2][3]) b[a[2][1]-'A']++;
	if(a[3][1]==a[3][2]&&a[3][1]==a[3][3]) b[a[3][1]-'A']++;
    if(a[1][1]==a[2][1]&&a[2][1]==a[3][1]) b[a[2][1]-'A']++;
    if(a[1][2]==a[2][2]&&a[1][2]==a[3][2]) b[a[1][2]-'A']++;
    if(a[1][3]==a[2][3]&&a[1][3]==a[3][3]) b[a[1][3]-'A']++;
	if(a[1][1]==a[2][2]&&a[2][2]==a[3][3]) b[a[1][1]-'A']++;
    if(a[1][3]==a[2][2]&&a[2][2]==a[3][1]) b[a[1][3]-'A']++;
    
    
    if(a[1][1]==a[1][2]&&a[1][1]!=a[1][3]&&t[a[1][1]-'A'+a[1][3]-'A']==0) t[a[1][1]-'A'+a[1][3]-'A']++;
    if(a[1][1]==a[1][3]&&a[1][1]!=a[1][2]&&t[a[1][1]-'A'+a[1][2]-'A']==0) t[a[1][1]-'A'+a[1][2]-'A']++;
    if(a[1][2]==a[1][3]&&a[1][1]!=a[1][2]&&t[a[1][1]-'A'+a[1][2]-'A']==0) t[a[1][1]-'A'+a[1][2]-'A']++;
    if(a[2][1]==a[2][2]&&a[2][1]!=a[2][3]&&t[a[2][1]-'A'+a[2][3]-'A']==0) t[a[2][1]-'A'+a[2][3]-'A']++;
    if(a[2][1]==a[2][3]&&a[2][1]!=a[2][2]&&t[a[2][1]-'A'+a[2][2]-'A']==0) t[a[2][1]-'A'+a[2][2]-'A']++;
    if(a[2][2]==a[2][3]&&a[2][1]!=a[2][2]&&t[a[2][1]-'A'+a[2][2]-'A']==0) t[a[2][1]-'A'+a[2][2]-'A']++;
    if(a[3][1]==a[3][2]&&a[3][1]!=a[3][3]&&t[a[3][1]-'A'+a[3][3]-'A']==0) t[a[3][1]-'A'+a[3][3]-'A']++;
    if(a[3][1]==a[3][3]&&a[3][1]!=a[3][2]&&t[a[3][1]-'A'+a[3][2]-'A']==0) t[a[3][1]-'A'+a[3][2]-'A']++;
    if(a[3][2]==a[3][3]&&a[3][1]!=a[3][2]&&t[a[3][1]-'A'+a[3][2]-'A']==0) t[a[3][1]-'A'+a[3][2]-'A']++;
	
	if(a[1][1]==a[2][1]&&a[1][1]!=a[3][1]&&t[a[1][1]-'A'+a[3][1]-'A']==0) t[a[1][1]-'A'+a[3][1]-'A']++;
	if(a[1][1]==a[3][1]&&a[1][1]!=a[2][1]&&t[a[1][1]-'A'+a[2][1]-'A']==0) t[a[1][1]-'A'+a[2][1]-'A']++;
    if(a[2][1]==a[3][1]&&a[2][1]!=a[1][1]&&t[a[2][1]-'A'+a[1][1]-'A']==0) t[a[2][1]-'A'+a[1][1]-'A']++;
    if(a[1][2]==a[2][2]&&a[1][2]!=a[3][2]&&t[a[1][2]-'A'+a[3][2]-'A']==0) t[a[1][1]-'A'+a[3][1]-'A']++;
	if(a[1][2]==a[3][2]&&a[1][2]!=a[2][2]&&t[a[1][2]-'A'+a[2][2]-'A']==0) t[a[1][1]-'A'+a[2][1]-'A']++;
    if(a[2][2]==a[3][2]&&a[2][2]!=a[1][2]&&t[a[2][2]-'A'+a[1][2]-'A']==0) t[a[2][1]-'A'+a[1][1]-'A']++;
    if(a[1][3]==a[2][3]&&a[1][3]!=a[3][3]&&t[a[1][3]-'A'+a[3][3]-'A']==0) t[a[1][1]-'A'+a[3][1]-'A']++;
	if(a[1][3]==a[3][3]&&a[1][3]!=a[2][3]&&t[a[1][3]-'A'+a[2][3]-'A']==0) t[a[1][1]-'A'+a[2][1]-'A']++;
    if(a[2][3]==a[3][3]&&a[2][3]!=a[1][3]&&t[a[2][3]-'A'+a[1][3]-'A']==0) t[a[2][1]-'A'+a[1][1]-'A']++;


	if(a[1][1]==a[2][2]&&a[1][1]!=a[3][3]&&t[a[1][1]-'A'+a[1][3]-'A']==0) t[a[1][1]-'A'+a[1][3]-'A']++;
	if(a[2][2]==a[3][3]&&a[1][1]!=a[3][3]&&t[a[1][1]-'A'+a[1][3]-'A']==0) t[a[1][1]-'A'+a[1][3]-'A']++;
	if(a[1][1]==a[3][3]&&a[1][1]!=a[2][2]&&t[a[1][1]-'A'+a[2][2]-'A']==0) t[a[1][1]-'A'+a[2][2]-'A']++;
	if(a[1][3]==a[2][2]&&a[1][3]!=a[3][1]&&t[a[1][3]-'A'+a[3][1]-'A']==0) t[a[1][3]-'A'+a[3][1]-'A']++;
    if(a[1][3]==a[3][1]&&a[1][3]!=a[2][2]&&t[a[1][3]-'A'+a[2][2]-'A']==0) t[a[1][3]-'A'+a[2][2]-'A']++;
    if(a[2][2]==a[3][1]&&a[2][2]!=a[1][3]&&t[a[2][2]-'A'+a[1][3]-'A']==0) t[a[2][2]-'A'+a[1][3]-'A']++;
    for(int i=0;i<26;i++)
      if(b[i]>0) cs++;
    for(int j=0;j<52;j++)
      if(t[j]>0) op++;
	if(op-2>=0)  printf("%d\n%d",cs,op-2);
	else printf("%d\n0",cs);
	return 0;
}
