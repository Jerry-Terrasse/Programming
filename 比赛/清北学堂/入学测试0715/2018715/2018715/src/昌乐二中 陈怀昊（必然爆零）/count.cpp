#include<iostream>
#include<math.h>
#include<algorithm>
using namespace std;
char s[4][4];
int ansp=0,anst=0;
int main(){
	cin>>s[1][1]>>s[1][2]>>s[1][3];
	cin>>s[2][1]>>s[2][2]>>s[2][3];
	cin>>s[3][1]>>s[3][2]>>s[3][3];
	
	for(int i=1;i<=3;i++){
	  if(s[i][1]==s[i][2]&&s[i][2]==s[i][3])
	    ansp++;
	  if(s[1][i]==s[2][i]&&s[2][i]==s[3][i])
	    ansp++;
	}
	if( (s[1][1]==s[2][2]&&s[2][2]==s[3][3])||(s[1][3]==s[2][3]&&s[2][3]==s[3][1]) )
	  ansp++;
	
  	for(int i=1;i<=3;i++){
	  if( (s[i][1]==s[i][2])&&(s[i][2]!=s[i][3]) || (s[i][2]==s[i][3])&&(s[i][1]!=s[i][3]) || (s[i][1]==s[i][3])&&(s[i][2]!=s[i][3]) )
	    anst++;
	  if( (s[1][i]==s[2][i]&&s[2][i]!=s[3][i]) || (s[3][i]==s[2][i]&&s[1][i]!=s[3][i]) || (s[1][i]==s[3][i]&&s[2][i]!=s[3][i]) )
	    anst++;
	}
	if( (s[1][1]==s[2][2]&&s[2][2]!=s[3][3]) || (s[1][1]==s[3][3]&&s[2][2]==s[3][3]) || (s[3][3]==s[2][2]&&s[2][2]==s[1][1]) )
	  ansp++;
        if( (s[1][3]==s[2][2]&&s[2][2]!=s[3][1]) || (s[1][3]==s[3][1]&&s[2][2]==s[3][1]) || (s[3][1]==s[2][2]&&s[2][2]==s[1][3]) )
	  ansp++;
	 /* */
	cout<<ansp<<endl;
	cout<<anst;
	return 0;
}