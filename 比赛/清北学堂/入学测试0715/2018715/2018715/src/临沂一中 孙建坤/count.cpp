#include<iostream>
#include<cstdio>

using namespace std;

char a[4][4];

int main(){
	freopen("count.in","r",stdin);
	freopen("count.out","w".stdout);
for(int i = 1 ; i <= 3 ; i++)
		for(int j = 1 ; j <= 3 ; j++)
			cin>>a[i][j];
	if (a[1][1] == a[1][2] && a[1][2] == a[1][3] && a[2][1] != a[1][1] && a[2][2] != a[1][1] && a[2][3] != a[1][1] &&a[3][1] != a[1][1] && a[3][2] != a[1][1] && a[3][3] != a[1][1]) {
	cout<<"1\n";
	cout<<"1"<<endl;
}
	else if(a[2][1] == a[2][2] && a[2][2] == a[2][3] && a[2][1] != a[1][1] && a[2][2] != a[1][1] && a[2][3] != a[1][1] &&a[3][1] != a[2][1] && a[3][2] != a[2][1] && a[3][3] != a[2][1]){
		cout<<"1\n";
	cout<<"1"<<endl;
	}
	else if(a[3][1] == a[3][2] && a[3][2] == a[3][3] && a[1][1] != a[3][1] && a[2][2] != a[3][1] && a[2][3] != a[3][1] &&a[3][1] != a[2][1] && a[3][2] != a[2][1] && a[3][3] != a[2][1]){
	cout<<"1\n";
	cout<<"1"<<endl;
	}
	else if (a[1][1] == a[2][1] && a[1][1] == a[3][1] && a[2][1] != a[1][1] && a[3][1] != a[1][1] && a[2][2] != a[1][1] &&a[2][3] != a[1][1] && a[3][2] != a[1][1] && a[3][3] != a[1][1]) {
	cout<<"1\n";
	cout<<"1"<<endl;
}
	else if (a[1][2] == a[2][2] && a[3][2] == a[2][3] && a[1][2] != a[1][1] && a[1][2] != a[3][1] && a[1][2] != a[2][1] &&a[1][2] != a[2][3] && a[1][2] != a[3][1] && a[3][3] != a[1][2]) {
	cout<<"1\n";
	cout<<"1"<<endl;
}
	else if (a[1][3] == a[2][3] && a[1][3] == a[3][3] && a[1][3] != a[1][1] && a[1][3] != a[1][2] && a[1][3] != a[2][1] &&a[1][3] != a[2][2] && a[1][3] != a[3][1] && a[1][3] != a[3][2]) {
	cout<<"1\n";
	cout<<"1"<<endl;
}
else if (a[1][1] == a[2][2] && a[1][1] == a[3][3] && a[1][2] != a[1][1] && a[1][3] != a[1][1] && a[2][1] != a[1][1] &&a[3][1] != a[1][1] && a[2][3] != a[1][1] && a[3][2] != a[1][1]) {
	cout<<"1\n";
	cout<<"1"<<endl;
}
else if (a[1][3] == a[2][2] && a[2][2] == a[3][1] && a[2][2] != a[1][1] && a[2][2] != a[1][2] && a[2][2] != a[2][1] &&a[2][2] != a[2][3] && a[2][2] != a[3][2] && a[3][3] != a[2][2]) {
	cout<<"1\n";
	cout<<"1"<<endl;
}
else{
	cout<<"1\n";
	cout<<"0"<<endl;
}

         fclose(stdin);
		 fclose(stdout);   
		 return 0;   

}



















