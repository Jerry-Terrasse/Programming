#include<bits/stdc++.h>
using namespace std;
int ans1=0,ans2=0;
char a[4][4];
int s[4][4];
bool f1[30],f2[30][30];
int main(){
	
	freopen("count.in","r",stdin);
	freopen("count.out","w",stdout);
	
	for(int i=1;i<=3;i++){
		for(int j=1;j<=3;j++){
			scanf("%c",&a[i][j]);
			s[i][j]=a[i][j]-'A'+1;
		}
		scanf("\n");
	}
	for(int i=1;i<=3;i++){
		if(s[i][1]==s[i][2]&&s[i][3]==s[i][2]) f1[s[i][1]]=1;
		else{
			if(s[i][1]==s[i][2]) f2[s[i][1]][s[i][3]]=1,f2[s[i][3]][s[i][1]]=1;
			if(s[i][3]==s[i][2]) f2[s[i][1]][s[i][3]]=1,f2[s[i][3]][s[i][1]]=1;
			if(s[i][1]==s[i][3]) f2[s[i][2]][s[i][3]]=1,f2[s[i][3]][s[i][2]]=1;
		}
		if(s[1][i]==s[2][i]&&s[3][i]==s[2][i]) f1[s[1][i]]=1;
		else{
			if(s[1][i]==s[2][i]) f2[s[1][i]][s[3][i]]=1,f2[s[3][i]][s[1][i]]=1;
			if(s[2][i]==s[3][i]) f2[s[1][i]][s[3][i]]=1,f2[s[3][i]][s[1][i]]=1;
			if(s[1][i]==s[3][i]) f2[s[2][i]][s[3][i]]=1,f2[s[3][i]][s[2][i]]=1;
		}
	}
	
	if(s[1][1]==s[2][2]&&s[3][3]==s[2][2]) f1[s[2][2]]=1;
	else{
		if(s[1][1]==s[2][2]) f2[s[1][1]][s[3][3]]=1,f2[s[3][3]][s[1][1]]=1;
		if(s[3][3]==s[2][2]) f2[s[1][1]][s[3][3]]=1,f2[s[3][3]][s[1][1]]=1;
		if(s[3][3]==s[1][1]) f2[s[2][2]][s[3][3]]=1,f2[s[3][3]][s[2][2]]=1;
	}
	if(s[3][1]==s[2][2]&&s[1][3]==s[2][2]) f1[s[2][2]]=1;
	else{
		if(s[3][1]==s[2][2]) f2[s[3][1]][s[3][1]]=1,f2[s[1][3]][s[3][1]]=1;
		if(s[1][3]==s[2][2]) f2[s[3][1]][s[3][1]]=1,f2[s[1][3]][s[3][1]]=1;
		if(s[1][3]==s[3][1]) f2[s[2][2]][s[3][1]]=1,f2[s[3][1]][s[2][2]]=1;
	}
	for(int i=1;i<=26;i++) if(f1[i]) ans1++;
	for(int i=1;i<=26;i++) for(int j=1;j<=26;j++) if(f2[i][j]) ans2++;
	printf("%d\n%d",ans1,ans2/2);
	return 0;
}
