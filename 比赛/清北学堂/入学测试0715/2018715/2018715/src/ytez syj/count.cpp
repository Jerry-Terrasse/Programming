#include<iostream>
#include<cstdio>
#include<cstring>
#include<string>
#include<cmath>
#include<algorithm>
using namespace std;
char a[4][4];
bool f[100][100]; 
int ans1,ans2;
int main()
{
	freopen("count.in","r",stdin);
	freopen("count.out","w",stdout);
	memset(f,0,sizeof(f));
	for(int i=1;i<=3;i++)
	  for(int j=1;j<=3;j++)
	    cin>>a[i][j];
	//输入 
	if(a[1][1]==a[1][2]&&a[1][2]==a[1][3]){f[a[1][1]][a[1][1]]=1;ans1++;}
	 else if((a[1][1]==a[1][2]||a[1][1]==a[1][3])&&f[a[1][2]][a[1][3]]==0){f[a[1][2]][a[1][3]]=f[a[1][3]][a[1][2]]=1;ans2++;}
	 else if(a[1][2]==a[1][3]&&f[a[1][1]][a[1][2]]==0){f[a[1][1]][a[1][2]]=f[a[1][2]][a[1][1]]=1;ans2++;}
	 
	if(a[2][1]==a[2][2]&&a[2][2]==a[2][3]&&f[a[2][1]][a[2][1]]==0){f[a[2][1]][a[2][1]]=1;ans1++;}
	  else if((a[2][1]==a[2][2]||a[2][1]==a[2][3])&&f[a[2][2]][a[2][3]]==0){f[a[2][2]][a[2][3]]=f[a[2][3]][a[2][2]]=1;ans2++;}
	 else if(a[2][2]==a[2][3]&&f[a[2][1]][a[2][2]]==0){f[a[2][1]][a[2][2]]=f[a[2][2]][a[2][1]]=1;ans2++;}
	 
	if(a[3][1]==a[3][2]&&a[3][2]==a[3][3]&&f[a[3][1]][a[3][1]]==0){f[a[3][1]][a[3][1]]=1;ans1++;}
	 else if((a[3][1]==a[3][2]||a[3][1]==a[3][3])&&f[a[3][2]][a[3][3]]==0){f[a[3][2]][a[3][3]]=f[a[3][3]][a[3][2]]=1;ans2++;}
	 else if(a[3][2]==a[3][3]&&f[a[3][1]][a[3][2]]==0){f[a[3][1]][a[3][2]]=f[a[3][2]][a[3][1]]=1;ans2++;}
	 //行 
	if(a[1][1]==a[2][1]&&a[2][1]==a[3][1]&&f[a[1][1]][a[1][1]]==0){f[a[1][1]][a[1][1]]=1;ans1++;}
	else if((a[1][1]==a[2][1]||a[1][1]==a[3][1])&&f[a[2][1]][a[3][1]]==0){f[a[2][1]][a[3][1]]=f[a[3][1]][a[2][1]]=1;ans2++;}
	 else if(a[2][1]==a[3][1]&&f[a[1][1]][a[2][1]]==0){f[a[1][1]][a[2][1]]=f[a[2][1]][a[1][1]]=1;ans2++;}
	 
	if(a[1][2]==a[2][2]&&a[2][2]==a[3][2]&&f[a[1][2]][a[1][2]]==0){f[a[1][2]][a[1][2]]=1;ans1++;}
	 else if((a[1][2]==a[2][2]||a[1][2]==a[3][2])&&f[a[2][2]][a[3][2]]==0){f[a[2][2]][a[3][2]]=f[a[3][2]][a[2][2]]=1;ans2++;}
	 else if(a[2][2]==a[3][2]&&f[a[1][2]][a[2][2]]==0){f[a[1][2]][a[2][2]]=f[a[2][2]][a[1][2]]=1;ans2++;}
	if(a[1][3]==a[2][3]&&a[2][3]==a[3][3]&&f[a[1][3]][a[1][3]]==0){f[a[1][3]][a[1][3]]=1;ans1++;}
	 else if((a[1][3]==a[2][3]||a[1][3]==a[3][3])&&f[a[2][3]][a[3][3]]==0){f[a[2][3]][a[3][3]]=f[a[3][3]][a[2][3]]=1;ans2++;}
	 else if(a[2][3]==a[3][3]&&f[a[1][3]][a[2][3]]==0){f[a[1][3]][a[2][3]]=f[a[2][3]][a[1][3]]=1;ans2++;}
	 
	//列
	if(a[1][1]==a[2][2]&&a[2][2]==a[3][3]&&f[a[1][1]][a[1][1]]==0){f[a[1][1]][a[1][1]]=1;ans1++;}
	 else if((a[1][1]==a[2][2]||a[1][1]==a[3][3])&&f[a[2][2]][a[3][3]]==0){f[a[2][2]][a[3][3]]=f[a[3][3]][a[2][2]]=1;ans2++;}
	 else if(a[2][2]==a[3][3]&&f[a[1][1]][a[2][2]]==0){f[a[1][1]][a[2][2]]=f[a[2][2]][a[1][1]]=1;ans2++;}
	 
	if(a[1][3]==a[2][2]&&a[2][2]==a[3][1]&&f[a[1][3]][a[1][3]]==0){f[a[1][3]][a[1][3]]=1;ans1++;}
	 else if((a[1][3]==a[2][2]||a[1][3]==a[3][1])&&f[a[2][2]][a[3][1]]==0){f[a[2][2]][a[3][1]]=f[a[3][1]][a[2][2]]=1;ans2++;}
	 else if(a[2][2]==a[3][1]&&f[a[1][3]][a[2][2]]==0){f[a[1][3]][a[2][2]]=f[a[2][2]][a[1][3]]=1;ans2++;}
	 //对角线 
	cout<<ans1<<endl;
	cout<<ans2<<endl; 
	return 0;
}
